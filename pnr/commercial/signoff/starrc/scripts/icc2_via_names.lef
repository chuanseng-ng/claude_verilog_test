VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

VIA mcon_cc DEFAULT
  LAYER li1 ; RECT -0.085 -0.085 0.085 0.085 ;
  LAYER mcon ; RECT -0.085 -0.085 0.085 0.085 ;
  LAYER met1 ; RECT -0.145 -0.115 0.145 0.115 ;
END mcon_cc

VIA via_cc DEFAULT
  LAYER met1 ; RECT -0.160 -0.130 0.160 0.130 ;
  LAYER via ; RECT -0.075 -0.075 0.075 0.075 ;
  LAYER met2 ; RECT -0.130 -0.160 0.130 0.160 ;
END via_cc

VIA via2_cc DEFAULT
  LAYER met2 ; RECT -0.140 -0.185 0.140 0.185 ;
  LAYER via2 ; RECT -0.100 -0.100 0.100 0.100 ;
  LAYER met3 ; RECT -0.165 -0.165 0.165 0.165 ;
END via2_cc

VIA via3_cc DEFAULT
  LAYER met3 ; RECT -0.190 -0.160 0.190 0.160 ;
  LAYER via3 ; RECT -0.100 -0.100 0.100 0.100 ;
  LAYER met4 ; RECT -0.165 -0.165 0.165 0.165 ;
END via3_cc

VIA via4_cc DEFAULT
  LAYER met4 ; RECT -0.590 -0.590 0.590 0.590 ;
  LAYER via4 ; RECT -0.400 -0.400 0.400 0.400 ;
  LAYER met5 ; RECT -0.710 -0.710 0.710 0.710 ;
END via4_cc

END LIBRARY
